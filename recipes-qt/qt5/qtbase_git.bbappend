PACKAGECONFIG_append = " accessibility fontconfig gles2 linuxfb"
PACKAGECONFIG_remove = "examples tests"
